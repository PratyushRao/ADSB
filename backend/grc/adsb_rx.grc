options:
  parameters:
    description: 'ADS-B 1090 MHz receiver: SDR/file -> |IQ| -> Mode-S PPM demod'
    generate_options: qt_gui
    id: adsb_rx
    output_language: python
    title: ADS-B 1090 MHz Receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Mode-S demod requires exactly 2 Msps
    value: 2e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: 1090e6
  states: {}
- name: gain
  id: variable
  parameters:
    comment: RTL-SDR tuner gain (dB). Try 30-49.
    value: '40'
  states: {}
- name: iq_file
  id: variable
  parameters:
    comment: 'rtl_sdr-format capture (unsigned 8-bit IQ, 2 Msps). Make one with tools/gen_test_iq.py or: rtl_sdr -f 1090e6 -s 2e6 -g 40 capture.bin'
    value: '''test_adsb.bin'''
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    comment: |-
      LIVE SDR: select and press E to enable,
      then disable the file source chain (D).
    center_freq: freq
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: FILE PLAYBACK (works without an SDR)
    file: iq_file
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-127.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/127.5
    type: float
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle2
  parameters:
    comment: Plays the file in real time
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    comment: '|IQ| envelope'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      ADS-B PPM Demodulator (1090 MHz Mode-S)

      Input: |IQ| magnitude at 2 Msps.
      Detects Mode-S preambles, slices PPM bits (phase-tracking + Viterbi
      fallback), checks CRC-24 (fixes 1-bit errors) and prints valid frames
      as *HEX; lines. Valid frames are also published as PDUs on "frames".

      This wraps AdsbPpmDemod from backend/dsp_demod.py, so GRC and the web
      backend run exactly the same DSP code. Edit the DSP there, not here.
      """
      import os
      import sys

      # Find backend/dsp_demod.py: next to the generated script (../), via
      # ADSB_BACKEND_DIR, or relative to where GRC was launched.
      _here = os.path.dirname(os.path.abspath(globals().get("__file__", os.path.join(os.getcwd(), "x"))))
      for _p in (os.environ.get("ADSB_BACKEND_DIR"), os.path.join(_here, ".."), os.path.join(os.getcwd(), "..")):
          if _p and os.path.isfile(os.path.join(_p, "dsp_demod.py")):
              _p = os.path.abspath(_p)
              if _p not in sys.path:
                  sys.path.insert(0, _p)
              break

      import dsp_demod


      class blk(dsp_demod.AdsbPpmDemod):
          """ADS-B PPM Demod: preamble detect, bit slicing, CRC-24 check."""

          def __init__(self, min_snr_db=8.0, print_frames=True):
              dsp_demod.AdsbPpmDemod.__init__(
                  self, sample_rate=2e6, min_snr_db=min_snr_db,
                  on_frame=self._print_frame if print_frames else None)

          def _print_frame(self, hexmsg, ts, rssi_db):
              print(f"*{hexmsg};   {rssi_db:6.1f} dBFS", flush=True)
    min_snr_db: '8.0'
    print_frames: 'True'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    type: float
    name: '"Mode-S pulses |IQ| (triggered on preamble)"'
    size: '300'
    srate: samp_rate
    grid: 'True'
    autoscale: 'True'
    ymin: '0'
    entags: 'False'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_level: '0.15'
    tr_delay: '5e-6'
    ctrlpanel: 'True'
    legend: 'False'
    label1: '|IQ|'
    color1: '"blue"'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_deinterleave_0, '0']
- [blocks_deinterleave_0, '0', blocks_float_to_complex_0, '0']
- [blocks_deinterleave_0, '1', blocks_float_to_complex_0, '1']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_mag_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_complex_to_mag_0, '0', epy_block_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
